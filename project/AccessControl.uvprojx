# Keil uVision project AccessControl.uvprojx, settings and files
target AccessControl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AccessControl +hex
  AfterMake: fromelf --bin --output "$Lbin\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,UWB_DEVICE_TYPE=UWB_DEVICE_TAG
  c include: ..\app\include;..\bsp\include;..\Libraries\CMSIS;..\Libraries\STM32L4xx_HAL_Driver\Inc;..\Libraries\CMSIS\Device\STM32L4xx\Include;..\Libraries\Core\Include;..\Libraries\CMSIS\DSP\Include;..\Libraries\STM32_Cryptographic\include;..\update;..\app\decadriver;..\app\platform;..\app\dw_app;..\app\madgwick_app;..\app\transGPS_app
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group bsp
    ../bsp/source/: bsp_uart.c bsp_spi.c bsp.c bsp_timer.c w25qxx.c g_fun.c bsp_adc.c bsp_lptim.c bsp_exti.c bsp_gpio.c bsp_store.c bsp_bluetooth.c bsp_led.c bsp_key.c bsp_iic.c bsp_rtk.c bsp_eeprom.c bsp_cw2015.c bsp_wt588e02b.c bsp_selfcheck.c bsp_4g.c bsp_dw1000.c bsp_dw1000_diag.c bsp_dw1000_official.c
    ../bsp/include/: bsp.h
  group app
    ../app/source/: main.c app_glovar.c app_tool.c lowpower.c iap.c vFile.c IAP_bsdiff.c app_warn.c app_ly.c app_gps.c app_4G.c 4G_Comm.c app_cuart.c app_workplan.c IMU_Acc.c lsm6dsl_reg.c app_WDG.c uwb_ranging.c uwb_tdma.c uwb_anchor.c uwb_data_transfer.c app_cmd.c
    ../app/include/: main.h
  group CMSIS
    ../Libraries/CMSIS/Device/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../Libraries/CMSIS/Device/STM32L4xx/Source/Templates/arm/: startup_stm32l431xx.s
    ../bsp/source/: stm32l4xx_it.c
  group hal
    ../Libraries/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_iwdg.c
  group Cryptographic
    ../Libraries/STM32_Cryptographic/interface/: cmox_low_level_template.c
    ../Libraries/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group update
    ../update/: Dump.c Update.c
  group DecaDriver
    ../app/decadriver/: deca_device.c deca_params_init.c
  group DecaPlatform
    ../app/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c port.c
  group dw_app
    ../app/dw_app/: instance_tag.c dw_main.c instance_anchor.c
  group Madgwick_app
    ../app/madgwick_app/: madgwick_uwb_fusion.c
  group TransGps_app
    ../app/transGPS_app/: uwb_gps_transform.c
